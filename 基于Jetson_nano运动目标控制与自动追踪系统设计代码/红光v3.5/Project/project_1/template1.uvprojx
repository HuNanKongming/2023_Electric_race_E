# Keil uVision project template1.uvprojx, settings and files
target template1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\inc;..\..\Application;..\..\Driver\LED;..\..\Driver\Key;..\..\Middleware\ExternPara;..\..\Driver\Beep;..\..\Driver\Timer;..\..\Driver\Encoder;..\..\Driver\Delay;..\..\Driver\Sys;..\..\Driver\OLED;..\..\Driver\Commonhead;..\..\Driver\Init;..\..\Driver\MPU6050;..\..\Driver\RTT;..\..\Driver\left_control;..\..\Driver\right_control;..\..\Driver\TOF200C\core\inc;..\..\Driver\TOF200C\demo;..\..\Driver\TOF200C\platform\inc;..\..\Driver\USART1;..\..\Driver\USART2;..\..\Driver\USART3;..\..\Middleware\PID;..\..\Middleware\Timer;..\..\Middleware\Control;..\..\Middleware\Angle;..\..\Middleware\NVIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Application
    ../../Application/: main.c stm32f10x_it.c README.txt
  group Middleware
    ../../Middleware/Control/: control.c
    ../../Middleware/ExternPara/: ExternPara.c ExternPara.h
    ../../Middleware/display/: display.c
    ../../Middleware/Usart/: usart.c
    ../../Middleware/PID/: PID.c
    ../../Middleware/Timer/: Timer_IRQHandler.c
    ../../Middleware/Angle/: Angle.c
    ../../Driver/Commonhead/: commonhead.c
    ../../Middleware/NVIC/: nvic.c
  group Drivers
    ../../Driver/LED/: LED.c
    ../../Driver/Key/: key.c
    ../../Driver/Beep/: Beep.c
    ../../Driver/Timer/: timer.c
    ../../Driver/Encoder/: encoder.c
    ../../Driver/Delay/: delay.c
    ../../Driver/Init/: init.c
    ../../Driver/OLED/: OLED.c
    ../../Driver/Sys/: sys.c
    ../../Driver/MPU6050/: I2C_MPU6050.c I2C.c MPU6050.c
    ../../Driver/left_control/: left_control.c
    ../../Driver/right_control/: right_control.c
    ../../Driver/USART1/: usart1.c
    ../../Driver/USART2/: usart2.c
    ../../Driver/USART3/: usart3.c
  group MPU DMP
    ../../Driver/MPU6050/: inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h inv_mpu.c inv_mpu.h dmpKey.h dmpmap.h
  group RTT
    ../../Driver/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
